# Keil uVision project MyQuadrotor.uvprojx, settings and files
target Quadrotor (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyQuadrotor
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\BSP\IIC;..\BSP\LED;..\BSP\MPU6050;..\BSP\Systick;..\BSP\TIMER;..\BSP\Motors;..\BSP\EEPROM;..\BSP\TIM_IN;..\BSP\ADC;..\BSP\HMC5883L;..\BSP\NRF24L01;..\BSP\MS5611;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\DELAY;..\SYSTEM\SYSTEM;..\SYSTEM\USART;..\USER;..\APP\Control;..\APP\Data_Transfer;..\APP\IMU;..\APP\Rc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/Control/: Control.c
    ../APP/Data_Transfer/: Data_Transfer.c
    ../APP/IMU/: AHRS_IMU.c
    ../APP/Rc/: Rc.c
  group BSP
    ../BSP/MPU6050/: MPU6050.c
    ../BSP/HMC5883L/: HMC5883L.c
    ../BSP/NRF24L01/: NRF24L01.c
    ../BSP/MS5611/: MS5611.c
    ../BSP/Motors/: motors.c
    ../BSP/TIM_IN/: TIM_IN.C
    ../BSP/TIMER/: Timer.c
    ../BSP/IIC/: Analog_IIC.c
    ../BSP/LED/: Led.c
    ../BSP/Systick/: Systick.c
    ../SYSTEM/USART/: Usart.c
    ../BSP/EEPROM/: eeprom.c
    ../BSP/ADC/: ADC.c
  group SYSTEM
    ../SYSTEM/SYSTEM/: sys.c
    ../SYSTEM/DELAY/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
